# Keil uVision project demo_simple.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo_simple
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: ..\..\TivaWare_C_Series-2.1.1.71\driverlib\rvmdk;..\..\TivaWare_C_Series-2.1.1.71\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./: main.c led.c switch.c timer.c display.c sensor.c
  group driverlib
    ../../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
