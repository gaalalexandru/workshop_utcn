# Keil uVision project demo_ssOS.uvprojx, settings and files
target demo_ssOS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo_ssOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: .\inc;.\OS;.\3rd_party;..\..\TivaWare_C_Series-2.1.1.71;..\TivaWare_C_Series-2.1.1.71;.\application
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group OS
    ./OS/: os_core.c osasm.s os_hw.c
  group main
    ./: main.c
  group 3rd_party
    ./3rd_party/: Profile.c BSP_TM4C.c
  group Documentation
    ./: readme.txt
  group driverlib
    ../../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
  group Application
    ./application/: display.c led.c sensor.c timer_handler.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
